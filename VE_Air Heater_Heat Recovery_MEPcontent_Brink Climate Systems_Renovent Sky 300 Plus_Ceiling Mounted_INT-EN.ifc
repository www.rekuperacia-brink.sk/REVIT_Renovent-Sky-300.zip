Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-07-09T16:42:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 09 16:42:44 2018 * Host: B3ROBRAWR2791 * Database: C:\Users\CS\AppData\Local\Temp\{D06C0C1D-F215-48BA-8A3C-7A6971BFA72F}\ifc * Database version: 5507 * Database creation date: Mon Jul 09 16:42:42 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Jul 09 16:42:42 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 09 16:42:43 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcAirToAirHeatRecovery: Renovent Sky 300 Plus, VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky 300_Ceiling Mounted_INT-EN:Renovent Sky 300 Plus:1284456
In: V00
Type - Material: Color RAL 9016, Color RGB 036-036-036, Color RGB 062-062-062, Color RAL 7045
Type - Dimensions - Height: 310 mm; Length: 1185 mm; Width: 644 mm
Type - Electrical - Loads - Nominal Voltage: 230.002 V
Type - Identity Data - Article Description: Heat recovery unit; Article Type: Renovent Sky 300 Plus; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat recovery unit; EMCS Version: 4.0; ETIM Article Class: EC011285; Family Version: 11.17; GTIN: 8718391136056; Manufacturer: Brink Climate Systems; Manufacturer Art. No.: 422005; Manufacturer URL: www.brinkclimatesystems.nl/downloads_renovent-sky-300; MEPcontent Class: AIR_HEATER_HEAT_RECOVERY; Model: Renovent Sky 300 Plus; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Brink Climate Systems; Revit Version: 2017; Type Name: Renovent Sky 300 Plus; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 036-036-036; Grey 1: Color RGB 062-062-062; Grey 2: Color RAL 7045; Service Area: Color RGB 218-227-224; White: Color RAL 9016
Type - Other - Category: Mechanical Equipment; Family Name: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky 300_Ceiling Mounted_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: Brink Climate Systems
Constraints - Offset: 0 mm
Dimensions - Area: 3.51705 m2; Volume: 0.244515 m3
Electrical - Loads - Apparent Load: 0 W; Nominal Current: 0 A
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Heating Power: 0; System Classification: Sanitary,Supply Air,Exhaust Air,Supply Air,Return Air,Power
Mechanical - Flow - Deflate Flow: 0 m3/s; Fresh Air Flow: 0 m3/s; Return Flow: 0 m3/s; Supply Flow: 0 m3/s
Other - Angle Condition: 180 deg; Connector Geometry: 157 mm; Connectors Condition: 160 mm; Family: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky 300_Ceiling Mounted_INT-EN: Renovent Sky 300 Plus; Family and Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky 300_Ceiling Mounted_INT-EN: Renovent Sky 300 Plus; Service Area Bottom: 0 mm; Service Area Height: 320 mm; Service Area Top: 0 mm; Service Area Width: 644 mm; Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky 300_Ceiling Mounted_INT-EN: Renovent Sky 300 Plus; Type Id: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky 300_Ceiling Mounted_INT-EN: Renovent Sky 300 Plus
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Ceiling Mounted: yes; Mounting Service Area: no; Ø150 Connectors: no; Ø160 Connectors: yes; Show Service Area: no; Wall Mounted: no
